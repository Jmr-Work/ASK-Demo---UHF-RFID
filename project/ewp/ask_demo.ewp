# IAR project ask_demo.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2541F128 CC2541F128
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2541F128_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
  group (top)
    ../../: globals.h main.c
  group bsp
    ../../bsp/: mcu.c mcu.h radio.c radio.h
  group bsp/radios
    ../../bsp/radios/: cc1175.c cc1175.h cc1175_reg_config.c cc1175_reg_config.h cc1200.c cc1200.h cc1200_reg_config.c cc1200_reg_config.h cc12xx.c cc12xx.h cc12xx_reg_lib.c cc12xx_reg_lib.h temp_radio.h
  group bsp/targets
    ../../bsp/targets/: cc2541.c cc2541.h cc2541_demo.c cc2541_demo.h
  group bsp/targets/support
    ../../bsp/targets/support/: hal_types.h iar_bits.h iocc2541_jmr.h ioCC254x_bitdef.h
  group lib
    ../../lib/: commands.h rfid.c rfid.h signal.c signal.h
  group sys/demo
    ../../sys/demo/: demo_finite.c demo_finite.h
  group sys/ref
    ../../sys/ref/: stdcomments.h
  group sys/test
    ../../sys/test/: rfid_test.c rfid_test.h
